# Keil uVision project UCOSII-1.uvprojx, settings and files
target UCOSII-1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOSII-1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\USMART;..\SYSTEM\GPIO;..\SYSTEM\IIC;..\SYSTEM\pwm;..\HARDWARE\pos_sensor;..\HARDWARE\motor;..\SYSTEM\Malloc;..\HARDWARE\ITV0011;..\HARDWARE\PCF8591;..\HARDWARE\PF6847;..\SYSTEM\adc;..\TASK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h Globalconfig.h Globalconfig.c stm32f10x.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/pos_sensor/: position.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/PCF8591/: PCF8591.c
    ../HARDWARE/PF6847/: p6847.c
    ../HARDWARE/ITV0011/: ITV0011.c
    ../HARDWARE/gas/: gas.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c mydelay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/GPIO/: gpio.c
    ../SYSTEM/IIC/: myiic.c
    ../SYSTEM/pwm/: pwm.c
    ../SYSTEM/Malloc/: malloc.c
    ../SYSTEM/adc/: adc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: README.TXT
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group TASK
    ../TASK/: taskthread.c
